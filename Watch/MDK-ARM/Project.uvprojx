# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_DISCOVERY (6160000::V6.16::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_DISCOVERY
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,USE_USB_HS
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32F769I-Discovery;..\..\Drivers\BSP\Components\Common;..\..\hal_stm_lvgl\tft;..\..\hal_stm_lvgl\touchpad;..\..\Middlewares\Third_Party;..\..\Middlewares\Third_Party\mooncake\src;..\..\Middlewares\Third_Party\mooncake\src\builtin_apps\assets;..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\Middlewares\Third_Party\FatFs\src;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\Third_Party\ArduinoJson\src;..\Src\APP;..\Src\APP\Utils\DataCenter;..\Src\APP\Utils\PageManager;..\Src\APP\Utils\ResourceManager;..\Src\APP\Config;..\Src\APP\Common;..\Src\APP\Utils\lv_ext
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group User
    ../Src/: main.cpp stm32f7xx_it.c usbd_conf.c usbd_desc.c usbd_storage.c bsp_debug_usart.c new.cpp
  group MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/BSP/STM32F769I_DISCOVERY
    ../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c stm32f769i_discovery_sd.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../Drivers/BSP/Components/nt35510/: nt35510.c
    ../../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group lvgl
    ../../Middlewares/Third_Party/: lv_conf.h
    ../../Middlewares/Third_Party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../Middlewares/Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Middlewares/Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Middlewares/Third_Party/lvgl/src/extra/: lv_extra.c
    ../../Middlewares/Third_Party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Middlewares/Third_Party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Middlewares/Third_Party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Middlewares/Third_Party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Middlewares/Third_Party/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Middlewares/Third_Party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Middlewares/Third_Party/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Middlewares/Third_Party/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../Middlewares/Third_Party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Middlewares/Third_Party/lvgl/src/extra/others/msg/: lv_msg.c
    ../../Middlewares/Third_Party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Middlewares/Third_Party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Middlewares/Third_Party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Middlewares/Third_Party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Middlewares/Third_Party/lvgl/src/extra/widgets/win/: lv_win.c
    ../../Middlewares/Third_Party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../Middlewares/Third_Party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Middlewares/Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../Middlewares/Third_Party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../Middlewares/Third_Party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../Middlewares/Third_Party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Middlewares/Third_Party/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl_port
    ../../hal_stm_lvgl/tft/: tft.c
    ../../hal_stm_lvgl/touchpad/: touchpad.c
    ../../Middlewares/Third_Party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c
  group lvgl_demo
    ../../Middlewares/Third_Party/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../Middlewares/Third_Party/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../../Middlewares/Third_Party/lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../Middlewares/Third_Party/lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group mooncake
    ../../Middlewares/Third_Party/mooncake/src/app/: app_manager.cpp app_register.cpp
    ../../Middlewares/Third_Party/mooncake/src/framework/: framework.cpp
    ../../Middlewares/Third_Party/mooncake/src/simplekv/: simplekv.cpp
    ../../Middlewares/Third_Party/mooncake/src/: mooncake.cpp
  group mooncake/app
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/boot_anim/: boot_anim.cpp
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/launcher/: launcher.cpp
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/settings/: settings.cpp
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/sketchpad/: sketchpad.cpp
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/wf_spring_wreath/: wf_spring_wreath.cpp
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/wf_user_custom/: wf_user_custom.cpp
  group mooncake/assets
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/assets/fonts/fonts/: ui_font_OpenSansMedium96.c ui_font_OpenSansMediumItalic24.c
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/assets/icon/anim/walking/: ui_img_icon_lc_walking_00_png.c ui_img_icon_lc_walking_01_png.c ui_img_icon_lc_walking_02_png.c ui_img_icon_lc_walking_03_png.c ui_img_icon_lc_walking_04_png.c ui_img_icon_lc_walking_05_png.c ui_img_icon_lc_walking_06_png.c ui_img_icon_lc_walking_07_png.c ui_img_icon_lc_walking_08_png.c ui_img_icon_lc_walking_09_png.c ui_img_icon_lc_walking_10_png.c ui_img_icon_lc_walking_11_png.c ui_img_icon_lc_walking_12_png.c ui_img_icon_lc_walking_13_png.c ui_img_icon_lc_walking_14_png.c ui_img_icon_lc_walking_15_png.c ui_img_icon_lc_walking_16_png.c ui_img_icon_lc_walking_17_png.c ui_img_icon_lc_walking_18_png.c ui_img_icon_lc_walking_19_png.c ui_img_icon_lc_walking_20_png.c ui_img_icon_lc_walking_21_png.c ui_img_icon_lc_walking_22_png.c ui_img_icon_lc_walking_23_png.c ui_img_icon_lc_walking_24_png.c ui_img_icon_lc_walking_25_png.c ui_img_icon_lc_walking_26_png.c ui_img_icon_lc_walking_27_png.c ui_img_icon_lc_walking_28_png.c ui_img_icon_lc_walking_29_png.c ui_img_icon_lc_walking_30_png.c
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/assets/icon/anim/wf_spring_wreath/: ui_img_anim_spring_wreath_0_png.c ui_img_anim_spring_wreath_1_png.c ui_img_anim_spring_wreath_2_png.c ui_img_anim_spring_wreath_3_png.c ui_img_anim_spring_wreath_4_png.c ui_img_anim_spring_wreath_5_png.c ui_img_anim_spring_wreath_6_png.c ui_img_anim_spring_wreath_7_png.c ui_img_anim_spring_wreath_8_png.c ui_img_anim_spring_wreath_9_png.c ui_img_anim_spring_wreath_10_png.c ui_img_anim_spring_wreath_11_png.c ui_img_anim_spring_wreath_12_png.c ui_img_anim_spring_wreath_13_png.c ui_img_anim_spring_wreath_14_png.c ui_img_anim_spring_wreath_15_png.c ui_img_anim_spring_wreath_16_png.c ui_img_anim_spring_wreath_17_png.c ui_img_anim_spring_wreath_18_png.c ui_img_anim_spring_wreath_19_png.c ui_img_anim_spring_wreath_20_png.c ui_img_anim_spring_wreath_21_png.c ui_img_anim_spring_wreath_22_png.c ui_img_anim_spring_wreath_23_png.c ui_img_anim_spring_wreath_24_png.c ui_img_anim_spring_wreath_25_png.c ui_img_anim_spring_wreath_26_png.c
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/assets/icon/static/app_icons/: ui_img_app_icon_hdpi_badminton_png.c ui_img_app_icon_hdpi_birdhead_png.c ui_img_app_icon_hdpi_boxing_png.c ui_img_app_icon_hdpi_camera_png.c ui_img_app_icon_hdpi_canvas_png.c ui_img_app_icon_hdpi_cheers_png.c ui_img_app_icon_hdpi_location_png.c ui_img_app_icon_hdpi_music_png.c ui_img_app_icon_hdpi_pingpong_png.c ui_img_app_icon_hdpi_settings_png.c ui_img_app_icon_hdpi_sketchpad_png.c ui_img_app_icon_hdpi_weather_png.c ui_img_app_icon_hdpi_wf_spring_wreath_png.c ui_img_app_icon_hdpi_wf_user_custom_png.c ui_img_icon_hdpi_default_png.c
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/assets/icon/static/status/: ui_img_icon_battery_png.c ui_img_icon_ble_off_png.c ui_img_icon_ble_on_png.c ui_img_icon_note_off_png.c ui_img_icon_note_on_png.c ui_img_icon_wifi_off_png.c ui_img_icon_wifi_on_png.c
    ../../Middlewares/Third_Party/mooncake/src/builtin_apps/assets/icon/anim/walking_cycle/: ui_img_walking_cycle_00_png.c ui_img_walking_cycle_01_png.c ui_img_walking_cycle_02_png.c ui_img_walking_cycle_03_png.c ui_img_walking_cycle_04_png.c ui_img_walking_cycle_05_png.c ui_img_walking_cycle_06_png.c ui_img_walking_cycle_07_png.c ui_img_walking_cycle_08_png.c ui_img_walking_cycle_09_png.c ui_img_walking_cycle_10_png.c ui_img_walking_cycle_11_png.c ui_img_walking_cycle_12_png.c ui_img_walking_cycle_13_png.c ui_img_walking_cycle_14_png.c ui_img_walking_cycle_15_png.c
  group USB_Device/core
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_Device/Class
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c
  group FatFs/Option
    ../../Middlewares/Third_Party/FatFs/src/: ffsystem.c ffunicode.c
  group App
    ../Src/APP/: App.cpp App.h Version.h
  group App/Page
    ../Src/APP/Pages/: AppFactory.cpp
  group App/Page/Temp
    ../Src/APP/Pages/_Template/: Template.cpp TemplateModel.cpp TemplateView.cpp
  group App/Page/Startup
    ../Src/APP/Pages/StartUp/: StartUp.cpp StartUpModel.cpp StartUpView.cpp
  group App/Page/Dialplate
    ../Src/APP/Pages/Dialplate/: Dialplate.cpp DialplateModel.cpp DialplateView.cpp
  group App/Page/LiveMap
    ../Src/APP/Pages/LiveMap/: LiveMap.cpp LiveMapModel.cpp LiveMapView.cpp
  group App/Page/SystemInfos
    ../Src/APP/Pages/SystemInfos/: SystemInfos.cpp SystemInfosModel.cpp SystemInfosView.cpp
  group Utils/DataCenter
    ../Src/APP/Utils/DataCenter/: Account.cpp DataCenter.cpp
    ../Src/APP/Utils/DataCenter/PingPongBuffer/: PingPongBuffer.c
  group Utils/PageManager
    ../Src/APP/Utils/PageManager/: PageBase.cpp PM_Anim.cpp PM_Base.cpp PM_Drag.cpp PM_Router.cpp PM_State.cpp
  group Utils/ResourceManager
    ../Src/APP/Utils/ResourceManager/: ResourceManager.cpp
  group Utils/lv_ext
    ../Src/APP/Utils/lv_ext/: lv_anim_timeline_wrapper.c lv_obj_ext_func.cpp
  group Utils/lv_poly_line
    ../Src/APP/Utils/lv_poly_line/: lv_poly_line.cpp
  group Config
    ../Src/APP/Config/: Config.h
  group Common
    ../Src/APP/Common/DataProc/: DataProc.cpp
  group Resource
    ../Src/APP/Resource/: ResourcePool.cpp ResourcePool.h
  group Resource/image
    ../Src/APP/Resource/Image/: img_src_alarm.c img_src_battery.c img_src_battery_info.c img_src_bicycle.c img_src_compass.c img_src_gps_arrow_dark.c img_src_gps_arrow_default.c img_src_gps_arrow_light.c img_src_gps_pin.c img_src_gyroscope.c img_src_locate.c img_src_map_location.c img_src_menu.c img_src_origin_point.c img_src_pause.c img_src_satellite.c img_src_sd_card.c img_src_start.c img_src_stop.c img_src_storage.c img_src_system_info.c img_src_time_info.c img_src_trip.c img_src_bg1_png.c img_src_bg2_png.c img_src_bg3_png.c img_src_clockwise_hour_png.c img_src_clockwise_min_png.c img_src_clockwise_sec_png.c img_src_sec_dot_png.c
  group Resource/font
    ../Src/APP/Resource/Font/: font_agencyb_36.c font_bahnschrift_13.c font_bahnschrift_17.c font_bahnschrift_32.c font_bahnschrift_65.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
